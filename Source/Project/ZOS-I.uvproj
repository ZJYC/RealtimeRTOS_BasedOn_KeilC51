# Keil uVision project ZOS-I.uvproj, settings and files
target ZOS-I (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ZOS-I +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\ZOS-I\source\inc;..\ZOS-I\source\CPU
  group ZOS-I-C
    ../ZOS-I/source/src/: Int.c OS.c Hook.c
  group ZOS-I-H
    ../ZOS-I/source/inc/: OS.h OS_CFG.h
  group user
    ../user/: APP.c APP_Cfg.h 记录.txt
  group CPU
    ../ZOS-I/source/CPU/: OS_ASM.a51 OS_CPU.h
